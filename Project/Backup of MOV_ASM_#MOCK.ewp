# IAR project Backup of MOV_ASM_#MOCK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\source\Bootloader\Inc; ..\source\SREC\Inc; ..\source\Queue\Inc; ..\source\MKE16Z4_HAL_Driver\Driver_Inc; ..\source\MKE16Z4_HAL_Driver\HAL; ..\source\Utility; ..\source\Bootloader\Inc; ..\MKE16Z4; ..\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOV_ASM_#MOCK.srec
  ILINK.IlinkOutputFile: MOV_ASM_#MOCK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common/Queue
    ../source/Queue/Src/: fpt_emb_queue.c
    ../source/Queue/Inc/: fpt_emb_queue.h
  group Common/SREC
    ../source/SREC/Src/: fpt_emb_srec.c
    ../source/SREC/Inc/: fpt_emb_srec.h
  group Common/Utilities
    ../source/Utility/: fpt_emb_utility.c fpt_emb_utility.h
  group Core/Inc
    ../MKE16Z4/: fsl_device_registers.h MKE16Z4_features.h system_MKE16Z4.h
    ../source/Bootloader/Inc/: main.h
  group Core/Src
    ../source/Bootloader/Src/: main.c
  group Core/Startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c
  group Drivers/CMSIS/Device
    ../MKE16Z4/: MKE16Z4.h
  group Drivers/CMSIS/Include
    ../CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h core_cm7.h mpu_armv7.h
  group Drivers/MKE16Z4_HAL_Driver/Driver_Inc
    ../source/MKE16Z4_HAL_Driver/Driver_Inc/: mke16z4_clock.h mke16z4_core.h mke16z4_def.h mke16z4_flash.h mke16z4_lpuart.h mke16z4_port_gpio.h
  group Drivers/MKE16Z4_HAL_Driver/Driver_Src
    ../source/MKE16Z4_HAL_Driver/Driver_Src/: mke16z4_clock.c mke16z4_core.c mke16z4_flash.c mke16z4_lpuart.c mke16z4_port_gpio.c
  group Drivers/MKE16Z4_HAL_Driver/HAL
    ../source/MKE16Z4_HAL_Driver/HAL/: mke16z4_hal_clock.h mke16z4_hal_flash.h mke16z4_hal_lpuart.h mke16z4_hal_port_gpio.h
